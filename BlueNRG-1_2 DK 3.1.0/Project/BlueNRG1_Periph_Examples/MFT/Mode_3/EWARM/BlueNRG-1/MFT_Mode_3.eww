<?xml version='1.0' encoding='iso-8859-1'?>
<workspace>
  <project>
    <path>$WS_DIR$\MFT_Mode_3.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>BUILD_ALL</name>
      <member>
        <project>Mode_3</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>Mode_3</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>