<?xml version='1.0' encoding='iso-8859-1'?>
<workspace>
  <project>
    <path>$WS_DIR$\SPI_Slave_DMA.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>BUILD_ALL</name>
      <member>
        <project>Slave_Dma</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>Slave_Dma</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>