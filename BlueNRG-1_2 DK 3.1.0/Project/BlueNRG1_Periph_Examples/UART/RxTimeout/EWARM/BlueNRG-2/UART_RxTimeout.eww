<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\UART_RxTimeout.ewp</path>
  </project>
<batchBuild>
    <batchDefinition>
      <name>BUILD_ALL</name>
    <member>
        <project>RxTimeout</project>
      <configuration>Debug</configuration>
      </member>
    <member>
        <project>RxTimeout</project>
      <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



