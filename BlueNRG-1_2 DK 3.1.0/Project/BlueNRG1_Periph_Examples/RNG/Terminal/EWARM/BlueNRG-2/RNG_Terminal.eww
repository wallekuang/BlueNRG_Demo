<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RNG_Terminal.ewp</path>
  </project>
<batchBuild>
    <batchDefinition>
      <name>BUILD_ALL</name>
    <member>
        <project>Terminal</project>
      <configuration>Debug</configuration>
      </member>
    <member>
        <project>Terminal</project>
      <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



