# IAR project RADIO_OTA_ResetManager.ewp, settings and files
configuration Client (ARM)
  General.OGChipSelectEditMenu: BlueNRG-1 ST BlueNRG-1
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: ST_OTA_SERVICE_MANAGER_APPLICATION=1; ST_OTA_MANAGER_APPLICATION=1; DEBUG_; BLUENRG1_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_2
  ICCARM.CCIncludePath2: ..\..\; ..\..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc; ..\..\..\..\..\..\Library\hal\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RADIO_OTA_ResetManager_Client.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_OTA_ResetManager_Client.bin"
  ILINK.IlinkOutputFile: RADIO_OTA_ResetManager_Client.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_SIZE=0x2000
  ILINK.IlinkIcfFile: BlueNRG1.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Server_Ymodem (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SERVER_YMODEM; ST_OTA_SERVICE_MANAGER_APPLICATION=1; DEBUG_; BLUENRG1_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_2
  OBJCOPY.OOCOutputFile: RADIO_OTA_ResetManager_Server_Ymodem.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_OTA_ResetManager_Server_Ymodem.bin"
  ILINK.IlinkOutputFile: RADIO_OTA_ResetManager_Server_Ymodem.out
configuration Server_FixedImage (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ST_OTA_SERVICE_MANAGER_APPLICATION=1; _DEBUG; BLUENRG1_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_2
  OBJCOPY.OOCOutputFile: RADIO_OTA_ResetManager_Server_FixedImage.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_OTA_ResetManager_Server_FixedImage.bin"
  ILINK.IlinkOutputFile: RADIO_OTA_ResetManager_Server_FixedImage.out
  group Hal
    ../../../../../../Library/hal/src/: clock.c context_switch.s gp_timer.c hal_radio.c miscutil.c osal.c
  group Library
    ../../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_radio.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c misc.c
  group Platform_Layers
    ../../../../../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Led.c
  group Startup
    ../../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group Users
    ../../: binary_image_txrx_example.c BlueNRG1_it.c bluenrg1_it_stub.c RADIO_OTAClient_main.c RADIO_OTAServer_main.c RADIO_OTAServerFixedImage_main.c ymodem.c
