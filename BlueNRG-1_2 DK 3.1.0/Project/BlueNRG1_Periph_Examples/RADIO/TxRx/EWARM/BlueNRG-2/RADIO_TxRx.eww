<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RADIO_TxRx.ewp</path>
  </project>
<batchBuild>
    <batchDefinition>
      <name>BUILD_ALL</name>
    <member>
        <project>TxRx</project>
      <configuration>RX</configuration>
      </member>
    <member>
        <project>TxRx</project>
      <configuration>TX</configuration>
      </member>
    <member>
        <project>TxRx</project>
      <configuration>RX_Use_OTA_ResetManager</configuration>
      </member>
    <member>
        <project>TxRx</project>
      <configuration>TX_Use_OTA_ResetManager</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



