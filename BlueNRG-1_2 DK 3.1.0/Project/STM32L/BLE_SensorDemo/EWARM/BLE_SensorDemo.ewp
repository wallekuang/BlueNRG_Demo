# IAR project BLE_SensorDemo.ewp, settings and files
configuration Release_SPI (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152ZE ST STM32L152ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L152xE; STM32L1XX_XL; USE_STM32L1XX_STEVAL_IDB00xV1; USE_HAL_DRIVER; HCLK_32MHZ=1; USER_DEFINED_PLATFORM=USER_EVAL_PLATFORM; DEBUG=1; ENABLE_USART=1; BLUENRG1_NWK_COPROC; SPI_INTERFACE
  ICCARM.CCIncludePath2: ..\inc\; ..\..\..\..\Library\STM32L\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\Library\STM32L\Drivers\BSP\STM32L1xx_Nucleo\inc; ..\..\..\..\Library\STM32L\Drivers\BSP\STM32L1xx_Bluenrg1\inc; ..\..\..\..\Library\STM32L\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\STM32L1xx_HAL_BlueNRG1_Drivers\inc; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\HAL\inc; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\SimpleBlueNRG1_HCI\includes; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\SimpleBlueNRG1_HCI
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_SensorDemo_SPI.hex
  ILINK.IlinkOutputFile: BLE_SensorDemo_SPI.out
  ILINK.IlinkIcfFile: stm32l1xx_flash_nucleo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release_UART (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L152xE; STM32L1XX_XL; USE_STM32L1XX_STEVAL_IDB00xV1; USE_HAL_DRIVER; HCLK_32MHZ=1; USER_DEFINED_PLATFORM=USER_EVAL_PLATFORM; DEBUG=1; ENABLE_USART=1; BLUENRG1_NWK_COPROC; UART_INTERFACE
  OBJCOPY.OOCOutputFile: BLE_SensorDemo_UART.hex
  ILINK.IlinkOutputFile: BLE_SensorDemo_UART.out
configuration Release_UART_HWFlowCtrl (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L152xE; STM32L1XX_XL; USE_STM32L1XX_STEVAL_IDB00xV1; USE_HAL_DRIVER; HCLK_32MHZ=1; USER_DEFINED_PLATFORM=USER_EVAL_PLATFORM; DEBUG=1; ENABLE_USART=1; BLUENRG1_NWK_COPROC; UART_INTERFACE; DTM_UART_HW_FLOW_CTRL
  OBJCOPY.OOCOutputFile: BLE_SensorDemo_UART_HWFlowCtrl.hex
  ILINK.IlinkOutputFile: BLE_SensorDemo_UART_HWFlowCtrl.out
configuration Release_SPI_LowPower (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L152xE; STM32L1XX_XL; USE_STM32L1XX_STEVAL_IDB00xV1; USE_HAL_DRIVER; USER_DEFINED_PLATFORM=USER_EVAL_PLATFORM; BLUENRG1_NWK_COPROC; SYSCLK_MSI=1; ENABLE_MICRO_SLEEP=1; SPI_INTERFACE
  OBJCOPY.OOCOutputFile: BLE_SensorDemo_SPI_LowPower.hex
  ILINK.IlinkOutputFile: BLE_SensorDemo_SPI_LowPower.out
configuration Release_UART_LowPower (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L152xE; STM32L1XX_XL; USE_STM32L1XX_STEVAL_IDB00xV1; USE_HAL_DRIVER; USER_DEFINED_PLATFORM=USER_EVAL_PLATFORM; BLUENRG1_NWK_COPROC; SYSCLK_MSI=1; ENABLE_MICRO_SLEEP=1; UART_INTERFACE
  OBJCOPY.OOCOutputFile: BLE_SensorDemo_UART_LowPower.hex
  ILINK.IlinkOutputFile: BLE_SensorDemo_UART_LowPower.out
  group Application/EWARM
    ./: startup_stm32l152xe.s
  group Application/User
    ../src/: BLE_SensorDemo_main.c bluenrg_interface.c cube_hal_l1.c gatt_db.c hci_parser.c sensor.c stm32xx_it.c user_timer.c
  group Drivers/BSP/STM32L1xx_BlueNRG1
    ../../../../Library/STM32L/Drivers/BSP/STM32L1xx_BlueNRG1/src/: SDK_EVAL_GPIO.c SDK_EVAL_Spi.c SDK_EVAL_Uart.c
  group Drivers/BSP/STM32L1xx_Nucleo
    ../../../../Library/STM32L/Drivers/BSP/STM32L1xx_Nucleo/src/: SDK_EVAL_Com.c SDK_EVAL_Led.c
  group Drivers/CMSIS
    ../src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../Library/STM32L/Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c
  group Middlewares/STM32_BlueNRG1/HAL
    ../../../../Library/STM32L/Middlewares/ST/STM32_BlueNRG1/HAL/src/: clock.c gp_timer.c list.c low_power.c osal.c
  group Middlewares/STM32_BlueNRG1/HAL_Drivers
    ../../../../Library/STM32L/Middlewares/ST/STM32_BlueNRG1/STM32L1xx_HAL_BlueNRG1_Drivers/src/: stm32l1xx_hal_bluenrg1_spi.c
  group Middlewares/STM32_BlueNRG1/HCI
    ../../../../Library/STM32L/Middlewares/ST/STM32_BlueNRG1/SimpleBlueNRG1_HCI/hci/: bluenrg1_events.c bluenrg1_hci_le.c hci.c
  group Middlewares/STM32_BlueNRG1/HCI/Controller
    ../../../../Library/STM32L/Middlewares/ST/STM32_BlueNRG1/SimpleBlueNRG1_HCI/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
