# IAR project DTM.ewp, settings and files
configuration DTM_UART (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152ZE ST STM32L152ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32L152xE; STM32L1XX_XL; USE_STM32L1XX_STEVAL_IDB00xV1; USE_HAL_DRIVER; HCLK_32MHZ=1; SYSCLK_MSI=1; ENABLE_USART; USER_DEFINED_PLATFORM=USER_EVAL_PLATFORM; IRQ_RESET_PIN; UART_INTERFACE; DTM_UART
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\HAL\inc; ..\..\..\..\Library\STM32L\Drivers\BSP\STM32L1xx_BlueNRG1\inc; ..\..\..\..\Library\STM32L\Drivers\BSP\STM32L1xx_Nucleo\inc; ..\..\..\..\Library\STM32L\Drivers\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\Library\STM32L\Drivers\STM32L1xx_HAL_Driver\Inc; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\STM32L1xx_HAL_BlueNRG1_Drivers\inc; ..\..\..\..\Library\STM32L\Middlewares\ST\STM32_BlueNRG1\SimpleBlueNRG1_HCI\includes
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: STM32L_Nucleo_DTM_UART.hex
  ILINK.IlinkOutputFile: STM32L_Nucleo_DTM_UART.out
  ILINK.IlinkIcfFile: stm32l1xx_flash_nucleo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DTM_SPI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L152xE; STM32L1XX_XL; USE_STM32L1XX_STEVAL_IDB00xV1; USE_HAL_DRIVER; HCLK_32MHZ=1; SYSCLK_MSI=1; ENABLE_USART; USER_DEFINED_PLATFORM=USER_EVAL_PLATFORM; IRQ_RESET_PIN; DTM_SPI; SPI_INTERFACE
  OBJCOPY.OOCOutputFile: STM32L_Nucleo_DTM_SPI.hex
  ILINK.IlinkOutputFile: STM32L_Nucleo_DTM_SPI.out
configuration DTM_UART_HWFlowCtrl (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L152xE; STM32L1XX_XL; USE_STM32L1XX_STEVAL_IDB00xV1; USE_HAL_DRIVER; HCLK_32MHZ=1; SYSCLK_MSI=1; ENABLE_USART; USER_DEFINED_PLATFORM=USER_EVAL_PLATFORM; IRQ_RESET_PIN; UART_INTERFACE; DTM_UART; DTM_UART_HW_FLOW_CTRL
  OBJCOPY.OOCOutputFile: STM32L_Nucleo_DTM_UART_HWFlowCtrl.hex
  ILINK.IlinkOutputFile: STM32L_Nucleo_DTM_UART_HWFlowCtrl.out
  group Application/EWARM
    ./: startup_stm32l152xe.s
  group Application/User
    ../src/: bluenrg_interface.c cube_hal_l1.c hci_parser.c main.c stm32xx_it.c
  group Drivers/BSP/STM32L1xx_BlueNRG1
    ../../../../Library/STM32L/Drivers/BSP/STM32L1xx_BlueNRG1/src/: SDK_EVAL_GPIO.c SDK_EVAL_Spi.c SDK_EVAL_Uart.c
  group Drivers/BSP/STM32L1xx_Nucleo
    ../../../../Library/STM32L/Drivers/BSP/STM32L1xx_Nucleo/src/: SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Timers.c
  group Drivers/CMSIS
    ../src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../Library/STM32L/Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c
  group Middlewares/HCI
    ../../../../Library/STM32L/Middlewares/ST/STM32_BlueNRG1/SimpleBlueNRG1_HCI/hci/: bluenrg1_events.c bluenrg1_hci_le.c hci.c
  group Middlewares/HCI/Controller
    ../../../../Library/STM32L/Middlewares/ST/STM32_BlueNRG1/SimpleBlueNRG1_HCI/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/STM32_BlueNRG1/HAL
    ../../../../Library/STM32L/Middlewares/ST/STM32_BlueNRG1/HAL/src/: clock.c gp_timer.c list.c low_power.c osal.c
  group Middlewares/STM32_BlueNRG1/HAL_Drivers
    ../../../../Library/STM32L/Middlewares/ST/STM32_BlueNRG1/STM32L1xx_HAL_BlueNRG1_Drivers/src/: stm32l1xx_hal_bluenrg1_spi.c
