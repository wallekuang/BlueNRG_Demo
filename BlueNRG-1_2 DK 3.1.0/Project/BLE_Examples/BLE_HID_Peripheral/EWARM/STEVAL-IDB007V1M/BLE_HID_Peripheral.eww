<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BLE_HID_Peripheral.ewp</path>
  </project>
<batchBuild>
    <batchDefinition>
      <name>BUILD_ALL</name>
    <member>
        <project>BLE_HID_Peripheral</project>
      <configuration>HID_Keyboard</configuration>
      </member>
    <member>
        <project>BLE_HID_Peripheral</project>
      <configuration>HID_Mouse</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>



