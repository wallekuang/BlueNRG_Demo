<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BLE_Security.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>BUILD_ALL</name>
      <member>
        <project>BLE_Security</project>
        <configuration>Master_JustWorks</configuration>
      </member>
      <member>
        <project>BLE_Security</project>
        <configuration>Master_NumericComp</configuration>
      </member>
      <member>
        <project>BLE_Security</project>
        <configuration>Master_PassKey_Fixed</configuration>
      </member>
      <member>
        <project>BLE_Security</project>
        <configuration>Master_PassKey_Random</configuration>
      </member>
      <member>
        <project>BLE_Security</project>
        <configuration>Slave_JustWorks</configuration>
      </member>
      <member>
        <project>BLE_Security</project>
        <configuration>Slave_NumericComp</configuration>
      </member>
      <member>
        <project>BLE_Security</project>
        <configuration>Slave_PassKey_Fixed</configuration>
      </member>
      <member>
        <project>BLE_Security</project>
        <configuration>Slave_PassKey_Random</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


