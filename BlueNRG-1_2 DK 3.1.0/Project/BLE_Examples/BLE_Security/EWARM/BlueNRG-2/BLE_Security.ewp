# IAR project BLE_Security.ewp, settings and files
configuration Slave_PassKey_Random (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-2 ST BlueNRG-2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; SECURITY_MODE=PASSKEY_RANDOM_PIN; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_1
  ICCARM.CCIncludePath2: ..\..\inc\peripheral; ..\..\..\..\..\Library\hal\inc; ..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Bluetooth_LE\inc; ..\..\..\..\..\Library\BLE_Application\layers_inc; ..\..\..\..\..\Library\BLE_Application\Utils\inc; ..\..\..\..\..\Library\BLE_Application\OTA\inc; ..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc; ..\..\..\..\..\Library\BLE_Application\Profile_Central\includes
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_Security_Slave_PassKey_Random.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_Security_Slave_PassKey_Random.bin"
  ILINK.IlinkOutputFile: BLE_Security_Slave_PassKey_Random.out
  ILINK.IlinkIcfFile: BlueNRG2.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Library\Bluetooth_LE\library\libbluenrg1_stack.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Master_PassKey_Random (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\inc\central; ..\..\..\..\..\Library\hal\inc; ..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Bluetooth_LE\inc; ..\..\..\..\..\Library\BLE_Application\layers_inc; ..\..\..\..\..\Library\BLE_Application\Utils\inc; ..\..\..\..\..\Library\BLE_Application\OTA\inc; ..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc; ..\..\..\..\..\Library\BLE_Application\Profile_Central\includes
  OBJCOPY.OOCOutputFile: BLE_Security_Master_PassKey_Random.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_Security_Master_PassKey_Random.bin"
  ILINK.IlinkOutputFile: BLE_Security_Master_PassKey_Random.out
configuration Slave_PassKey_Fixed (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; SECURITY_MODE=PASSKEY_FIXED_PIN; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_1
  OBJCOPY.OOCOutputFile: BLE_Security_Slave_PassKey_Fixed.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_Security_Slave_PassKey_Fixed.bin"
  ILINK.IlinkOutputFile: BLE_Security_Slave_PassKey_Fixed.out
configuration Master_PassKey_Fixed (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: BLE_Security_Master_PassKey_Fixed.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_Security_Master_PassKey_Fixed.bin"
  ILINK.IlinkOutputFile: BLE_Security_Master_PassKey_Fixed.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Library\BLE_Application\Profile_Central\library\libmaster_library_bluenrg1.a
configuration Slave_JustWorks (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; SECURITY_MODE=JUST_WORKS; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_1
  OBJCOPY.OOCOutputFile: BLE_Security_Slave_JustWorks.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_Security_Slave_JustWorks.bin"
  ILINK.IlinkOutputFile: BLE_Security_Slave_JustWorks.out
configuration Master_JustWorks (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: BLE_Security_Master_JustWorks.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_Security_Master_JustWorks.bin"
  ILINK.IlinkOutputFile: BLE_Security_Master_JustWorks.out
  ILINK.IlinkAdditionalLibs: as above
configuration Slave_NumericComp (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; BLE_STACK_CONFIGURATION=BLE_STACK_FULL_CONFIGURATION; SECURITY_MODE=NUMERIC_COMPARISON; BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; USER_BUTTON=BUTTON_1
  OBJCOPY.OOCOutputFile: BLE_Security_Slave_NumericComp.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_Security_Slave_NumericComp.bin"
  ILINK.IlinkOutputFile: BLE_Security_Slave_NumericComp.out
configuration Master_NumericComp (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: BLE_Security_Master_NumericComp.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_Security_Master_NumericComp.bin"
  ILINK.IlinkOutputFile: BLE_Security_Master_NumericComp.out
  ILINK.IlinkAdditionalLibs: as above
  group HAL
    ../../../../../Library/hal/src/: clock.c context_switch.s miscutil.c osal.c sleep.c
  group Library
    ../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group Master_Library
    ../../../../../Library/BLE_Application/Profile_Central/library/: libmaster_library_bluenrg1.a
    ../../../../../Library/BLE_Application/Profile_Central/profiles/ble_profile/: master_events_CB.c
  group Platform_Layers
    ../../../../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Led.c
  group Stack
    ../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
    ../../../../../Library/cryptolib/: libcrypto.a
    ../../../../../Library/Bluetooth_LE/src/: stack_user_cfg.c
  group Startup
    ../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User_Central
    ../../src/central/: BlueNRG1_it.c C_main.c gatt_db.c
  group User_Peripheral
    ../../src/peripheral/: BLE_Security_Peripheral.c BlueNRG1_it.c gatt_db.c P_main.c
