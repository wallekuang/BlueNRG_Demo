<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DTM_Updater.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>BUILD_ALL</name>
      <member>
        <project>DTM_Updater</project>
        <configuration>Release_SPI</configuration>
      </member>
      <member>
        <project>DTM_Updater</project>
        <configuration>Release_UART_16MHz</configuration>
      </member>
      <member>
        <project>DTM_Updater</project>
        <configuration>Release_UART_32MHz</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


