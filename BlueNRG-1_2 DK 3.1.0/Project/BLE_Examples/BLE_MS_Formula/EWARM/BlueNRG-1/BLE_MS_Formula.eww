<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BLE_MS_Formula.ewp</path>
  </project>
  <batchBuild/>
</workspace>


