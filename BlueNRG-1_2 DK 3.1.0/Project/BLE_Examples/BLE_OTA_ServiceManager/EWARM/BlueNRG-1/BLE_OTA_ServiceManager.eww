<?xml version='1.0' encoding='iso-8859-1'?>
<workspace>
  <project>
    <path>$WS_DIR$\BLE_OTA_ServiceManager.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>BUILD_ALL</name>
      <member>
        <project>OTA_ResetManager</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>OTA_ResetManager</project>
        <configuration>ServiceManager</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>